# Keil uVision project TEST1.uvprojx, settings and files
target TEST1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TEST1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STDPERIPH_DRIVER,STM32F429_439xx,WICED_DISABLE_BOOTLOADER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../WiFi_SDK/include;../WiFi_SDK/WICED/WWD/include;../WiFi_SDK/WICED/platform/include;../WiFi_SDK/WICED/platform/MCU;../WiFi_SDK/WICED/platform/MCU/STM32F4xx;../WiFi_SDK/WICED/platform/MCU/STM32F4xx/peripherals;../WiFi_SDK/WICED/platform/MCU/STM32F4xx/peripherals/libraries/inc;../WiFi_SDK/WICED/platform/ARM_CM4;../WiFi_SDK/WICED/RTOS/FreeRTOS/WWD;../WiFi_SDK/WICED/WWD;../WiFi_SDK/libraries/utilities/TLV;../WiFi_SDK/libraries/utilities/ring_buffer;../WiFi_SDK/WICED/platform/GCC;../WiFi_SDK/WICED/network/LwIP/WWD;../WiFi_SDK/WICED/network/LwIP/WWD/FreeRTOS;../WiFi_SDK/WICED/network/LwIP/WWD/FreeRTOS/arch;../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src;../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/include;../WiFi_SDK/WICED/network/LwIP/WICED;../WiFi_SDK/WICED/security/PostgreSQL/include;../WiFi_SDK/WICED/security/BESL/host/WICED;../WiFi_SDK/WICED/RTOS/FreeRTOS/WICED;../WiFi_SDK/WICED/network/LwIP/ver2.0.3/port;../WiFi_SDK/WICED/security/BESL/crypto_internal;../WiFi_SDK/libraries/utilities/linked_list;../WiFi_SDK/WICED/security/BESL/mbedtls_open/include
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\TEST1_dma.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: app_audio.c app_input.c app_ui.c app_wifi.c mpu6050.c wm8978.c bsp_sdram.c bsp_lcd.c winter_girl_crop_rgb565.c main.c gpio.c freertos.c i2c.c ltdc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sdram.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group WiFi_SDK
    ../Core/Src/: wiced_port.c wifi_resources.c retarget.c wifi_platform_pins.c wiced_powersave_stub.c
    ../WiFi_SDK/WICED/platform/MCU/STM32F4xx/: platform_init.c
    ../WiFi_SDK/WICED/RTOS/FreeRTOS/WWD/ARM_CM3/: low_level_init.c
    ../WiFi_SDK/WICED/RTOS/FreeRTOS/WWD/: wwd_rtos.c
    ../WiFi_SDK/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c
    ../WiFi_SDK/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c
    ../WiFi_SDK/WICED/WWD/internal/chips/43362/: wwd_ap.c wwd_chip_specific_functions.c
    ../WiFi_SDK/WICED/WWD/internal/: wwd_ap_common.c wwd_debug.c wwd_eapol.c wwd_internal.c wwd_logging.c wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_thread.c wwd_thread_internal.c wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_sleep.c
    ../WiFi_SDK/WICED/platform/MCU/STM32F4xx/WWD/: wwd_SDIO.c wwd_platform.c
    ../WiFi_SDK/WICED/platform/MCU/: wwd_platform_separate_mcu.c
    ../WiFi_SDK/WICED/platform/MCU/STM32F4xx/peripherals/: platform_gpio.c
    ../WiFi_SDK/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_network.c
    ../WiFi_SDK/WICED/network/LwIP/WWD/FreeRTOS/: sys_arch.c
    ../WiFi_SDK/WICED/internal/: wiced_crypto.c
    ../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../WiFi_SDK/WICED/network/LwIP/ver2.0.3/src/netif/: ethernet.c ethernetif.c
    ../WiFi_SDK/resources/firmware/43362/: 43362A2_bin.c
    ../WiFi_SDK/WICED/platform/MCU/STM32F4xx/peripherals/libraries/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c
software components: CMSIS:CORE 6.1.1
